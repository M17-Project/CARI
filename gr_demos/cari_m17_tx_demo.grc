options:
  parameters:
    author: Wojciech Kaczmarski SP5WWP
    copyright: M17 Project 2024
    generate_options: qt_gui
    id: zmq_pub_fm
    output_language: python
    title: CARI M17 TX demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '64'
    freq: '0.5'
    offset: '0'
    phase: '0'
    samp_rate: '24000'
    type: byte
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: samples\2.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: 50/3
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    maxoutbuf: '960'
    minoutbuf: '960'
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1.0, 3.0, -1.0, -3.0)
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '5'
    interp: '5'
    ntaps: 8*5+1
    samp_rate: '5'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17018
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_repack_bits_bb_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle2_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_throttle2_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle2_0_0, '0', zeromq_pub_sink_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_float_to_char_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
