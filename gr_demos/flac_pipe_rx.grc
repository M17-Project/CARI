options:
  parameters:
    author: Wojciech Kaczmarski, SP5WWP
    copyright: M17 Foundation 2025
    generate_options: qt_gui
    id: flac_pipe_rx
    output_language: python
    title: FLAC pipe baseband source
  states: {}

blocks:
- name: channelizer_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 6.25e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 6.25e3
    win: window.WIN_HAMMING
  states: {}
- name: f_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '-62.5'
    step: '0.1'
    stop: '62.5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 48e3/(2.0*math.pi*800.0)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./flac_out
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ./flac_in
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '0x8000'
    vector_input: 'False'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2.0*math.pi*0.000045
    max_dev: '0.01'
    osps: '10'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_offset*1000.0
    decim: '1'
    samp_rate: samp_rate
    taps: channelizer_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: flac -s -d -c --force-raw-format --endian little --sign signed flac_enc | pv > flac_out
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    legend: 'False'
    samp_per_symbol: '10'
    size: '2000'
    srate: '48000'
    type: float
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label: Magnitude
    legend: 'False'
    type: complex
    ymax: '-40'
    ymin: '-100'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '48'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: 10*8+1
    samp_rate: '10'
    sym_rate: '1.0'
    type: fir_filter_fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_eye_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
