options:
  parameters:
    author: Wojciech Kaczmarski SP5WWP
    copyright: M17 Project 2024
    generate_options: qt_gui
    id: cari_loopback
    output_language: python
    title: CARI loopback FM repeater
  states: {}

blocks:
- name: rru_addr
  id: variable
  parameters:
    value: '"rru.mshome.net"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: analog_ctcss_squelch_ff_0
  id: analog_ctcss_squelch_ff
  parameters:
    freq: '127.3'
    gate: 'True'
    len: '0'
    level: '0.1'
    ramp: '0'
    rate: samp_rate
  states: {state: bypassed}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '128'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '128'
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    maxoutbuf: '960'
    minoutbuf: '960'
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '960'
    type: byte
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17018
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+rru_addr+":17017"'
    timeout: '100'
    type: byte
    vlen: '960'
  states: {}

connections:
- [analog_ctcss_squelch_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_char_to_float_0, '0', analog_ctcss_squelch_ff_0, '0']
- [blocks_float_to_char_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_char_to_float_0, '0']
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
