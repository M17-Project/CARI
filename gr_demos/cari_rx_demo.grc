options:
  parameters:
    author: Wojciech Kaczmarski SP5WWP
    copyright: M17 Project 2024
    generate_options: qt_gui
    id: zmq_test
    output_language: python
    title: RRU-BBU optical fiber link test w/ ZeroMQ (CARI)
  states: {}

blocks:
- name: addr
  id: variable
  parameters:
    value: '"192.168.137.85"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./dump.raw
    type: short
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '256.0'
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '960'
    type: byte
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '3'
    type: byte
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2.0*math.pi*0.0000015
    max_dev: '0.005'
    osps: '5'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '5'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    label1: Eye plot
    legend: 'False'
    samp_per_symbol: '5'
    size: '2400'
    srate: samp_rate
    type: float
    ymax: '127'
    ymin: '-127'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: RRU
    legend: 'False'
    size: '500'
    srate: samp_rate
    type: float
    ymax: '128'
    ymin: '-128'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: RRU
    legend: 'False'
    nconnections: '3'
    size: '100'
    srate: 1/0.04
    type: float
    ymax: '5'
    ymin: '0'
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: 8*5+1
    samp_rate: '5'
    sym_rate: '1'
    type: fir_filter_fff
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+addr+":17017"'
    timeout: '100'
    type: byte
    vlen: '960'
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+addr+":17020"'
    timeout: '100'
    type: byte
    vlen: '3'
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_0_0_1, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_char_to_float_0_0_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_char_to_float_0_0_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_float_to_short_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_0, '0']
- [zeromq_sub_source_0_0, '0', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
