options:
  parameters:
    author: Wojciech Kaczmarski SP5WWP
    copyright: M17 Project 2024
    generate_options: qt_gui
    id: zmq_pub
    output_language: python
    title: CARI SX1255 multicarrier TX demo
  states: {}

blocks:
- name: a0
  id: variable_qtgui_range
  parameters:
    label: a0
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.0'
  states: {}
- name: a1
  id: variable_qtgui_range
  parameters:
    label: a1
    start: '-2'
    step: '0.001'
    stop: '2'
    value: '0.0'
  states: {}
- name: a2
  id: variable_qtgui_range
  parameters:
    label: a2
    start: '-2'
    step: '0.001'
    stop: '2'
    value: '0.0'
  states: {}
- name: ch
  id: variable_qtgui_range
  parameters:
    label: ch
    start: '-7'
    step: '1'
    stop: '7'
    value: '0.0'
  states: {}
- name: chans
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ibal
  id: variable_qtgui_range
  parameters:
    label: I_bal
    start: '0.0'
    step: '0.001'
    stop: '1'
    value: '1.0'
  states: {}
- name: ioffs
  id: variable_qtgui_range
  parameters:
    label: I_offs
    start: '-1'
    step: '0.001'
    stop: '1'
    value: '-0.024'
  states: {}
- name: qbal
  id: variable_qtgui_range
  parameters:
    label: Q_bal
    start: '0.0'
    step: '0.001'
    stop: '1'
    value: '0.989'
  states: {}
- name: qoffs
  id: variable_qtgui_range
  parameters:
    label: Q_offs
    start: '-1'
    step: '0.001'
    stop: '1'
    value: '0.028'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: variable_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (800.0*2.0*math.pi)/samp_rate
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (800.0*2.0*math.pi)/samp_rate
  states: {}
- name: analog_frequency_modulator_fc_0_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (800.0*2.0*math.pi)/samp_rate
  states: {}
- name: analog_frequency_modulator_fc_0_0_1
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (800.0*2.0*math.pi)/samp_rate
  states: {}
- name: analog_frequency_modulator_fc_0_0_2
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (800.0*2.0*math.pi)/samp_rate
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0_1
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0_2
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_1
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '65535'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_1_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '65535'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ch*12.5e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ch*12.5e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: complex(ioffs, qoffs)
    type: complex
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-2*12.5e3/800.0'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1*12.5e3/800.0'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0*12.5e3/800.0'
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0_1
  id: blocks_add_const_vxx
  parameters:
    const: 1*12.5e3/800.0
    type: float
  states: {}
- name: blocks_add_const_vxx_1_0_2
  id: blocks_add_const_vxx
  parameters:
    const: 2*12.5e3/800.0
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '7'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: samples\1.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: samples\2.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: samples\3.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_1
  id: blocks_file_source
  parameters:
    file: samples\4.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_2
  id: blocks_file_source
  parameters:
    file: samples\5.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.0*1/chans
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.0*1/chans
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.0*1/chans
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.0*1/chans
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.0*1/chans
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_4
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.0*1/chans
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_5
  id: blocks_multiply_const_vxx
  parameters:
    const: 0.5*1/chans
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: ibal
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: qbal
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_0_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_0_0_0_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1.0, 3.0, -1.0, -3.0)
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1.0, 3.0, -1.0, -3.0)
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1.0, 3.0, -1.0, -3.0)
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1.0, 3.0, -1.0, -3.0)
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_2
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1.0, 3.0, -1.0, -3.0)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation
    differential: 'True'
    excess_bw: '0.5'
    samples_per_symbol: '10'
  states: {state: disabled}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.5'
    mod_code: '"gray"'
    samples_per_symbol: '10'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Embedded Python Block - a simple quadratic polynomial DPD model.\nout = a1*in + a2*in*abs(in) + a3*in*abs(in^2)"""

          def __init__(self, a1=1.0, a2=0.0, a3=0.0):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='AM/AM poly DPD',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.a1 = a1
              self.a2 = a2
              self.a3 = a3

          def work(self, input_items, output_items):
              """apply predistortion to samples"""
              output_items[0][:] = self.a1 * input_items[0] + self.a2 * input_items[0] * np.absolute(input_items[0]) + self.a3 * input_items[0] * np.absolute(np.power(input_items[0], 2.0))
              return len(output_items[0])
    a1: a0
    a2: a1
    a3: a2
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Saleh predistortion model"""

          def __init__(self, aa=1.0, ba=0.0, ap=0.0, bp=0.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Saleh Model',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.aa = aa
              self.ba = ba
              self.ap = ap
              self.bp = bp

          def work(self, input_items, output_items):
              """Apply Saleh model to complex baseband"""
              out_mag=(self.aa*np.absolute(input_items[0]))/(1.0+self.ba*np.absolute(input_items[0])*np.absolute(input_items[0]))
              out_phase=np.angle(input_items[0]) + (self.ap*np.absolute(input_items[0])*np.absolute(input_items[0]))/(1.0+self.bp*np.absolute(input_items[0])*np.absolute(input_items[0]))
              output_items[0][:] = out_mag * np.exp(1j*out_phase)
              return len(output_items[0])
    aa: variable_qtgui_range_0_0
    ap: variable_qtgui_range_0_2
    ba: variable_qtgui_range_0_1
    bp: variable_qtgui_range_0_3
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[0.000197695583, -0.000036008008, 0.000039274933, -0.000042729681, 0.000046380231, -0.000050233909, 0.000054298192, -0.000058581637, 0.000063093698, -0.000067841979, 0.000072835122, -0.000078084681, 0.000083598110, -0.000089382883, 0.000095450865, -0.000101811908, 0.000108473888, -0.000115452479, 0.000122752228, -0.000130388780, 0.000138369816, -0.000146707831, 0.000155412681, -0.000164496496, 0.000173970649, -0.000183847610, 0.000194140539, -0.000204860855, 0.000216021912, -0.000227635589, 0.000239717132, -0.000252279201, 0.000265338906, -0.000278908335, 0.000293002557, -0.000307635613, 0.000322822614, -0.000338579892, 0.000354925219, -0.000371873556, 0.000389441103, -0.000407643761, 0.000426497302, -0.000446020258, 0.000466230156, -0.000487148092, 0.000508779123, -0.000531162622, 0.000554284844, -0.000578200926, 0.000602911519, -0.000628429716, 0.000654789012, -0.000682009867, 0.000710106410, -0.000739100882, 0.000769017578, -0.000799879898, 0.000831710093, -0.000864524888, 0.000898346618, -0.000933209570, 0.000969132891, -0.001006124024, 0.001044228783, -0.001083451076, 0.001123831678, -0.001165386493, 0.001208141683, -0.001252120873, 0.001297351425, -0.001343861051, 0.001391678920, -0.001440834188, 0.001491353537, -0.001543265948, 0.001596600113, -0.001651385820, 0.001707652260, -0.001765429547, 0.001824743557, -0.001885623961, 0.001948097744, -0.002012195988, 0.002077949490, -0.002145392318, 0.002214557806, -0.002285481842, 0.002358200535, -0.002432749342, 0.002509164415, -0.002587478603, 0.002667726157, -0.002749934079, 0.002834138862, -0.002920363984, 0.003008649713, -0.003099031904, 0.003191555178, -0.003286272943, 0.003383233823, -0.003482479159, 0.003584041643, -0.003687936658, 0.003794173073, -0.003902780174, 0.004013833784, -0.004127461044, 0.004243770692, -0.004362665764, 0.004483723159, -0.004608044835, 0.004734784003, -0.004864364084, 0.004996752688, -0.005132001194, 0.005270156596, -0.005411266138, 0.005555377653, -0.005702541972, 0.005852809600, -0.006006228231, 0.006162849817, -0.006322727145, 0.006485910732, -0.006652453639, 0.006822411334, -0.006995833709, 0.007172781223, -0.007353305467, 0.007537465733, -0.007725317598, 0.007916920630, -0.008112333834, 0.008311618786, -0.008514836958, 0.008722049468, -0.008933319707, 0.009148710425, -0.009368288471, 0.009592119185, -0.009820272961, 0.010052815028, -0.010289816845, 0.010531347436, -0.010777479194, 0.011028286872, -0.011283845610, 0.011544230106, -0.011809518412, 0.012079788179, -0.012355120008, 0.012635598299, -0.012921307124, 0.013212332134, -0.013508755133, 0.013810681220, -0.014118168124, 0.014431364261, -0.014750303007, 0.015075112991, -0.015405902385, 0.015742752141, -0.016085765838, 0.016435061368, -0.016790748204, 0.017152932435, -0.017521725210, 0.017897245649, -0.018279622730, 0.018668981115, -0.019065434904, 0.019469113392, -0.019880161002, 0.020298700759, -0.020724890508, 0.021158860608, -0.021600764631, 0.022050752622, -0.022508985151, 0.022975626811, -0.023450847862, 0.023934820944, -0.024427722029, 0.024929734343, -0.025441045646, 0.025961852241, -0.026492356476, 0.027032768362, -0.027583302645, 0.028144185176, -0.028715646422, 0.029297928606, -0.029891280351, 0.030495960269, -0.031112233682, 0.031740377067, -0.032380675289, 0.033033425105, -0.033698936891, 0.034377533547, -0.035069554322, 0.035775348710, -0.036495285507, 0.037229732310, -0.037979087851, 0.038743749150, -0.039524148180, 0.040320737342, -0.041133986518, 0.041964390263, -0.042812456663, 0.043678702474, -0.044563673627, 0.045467961416, -0.046392201827, 0.047337052727, -0.048303158005, 0.049291168807, -0.050301865334, 0.051336162434, -0.052394612322, 0.053478306635, -0.054588037999, 0.055724798156, -0.056889588450, 0.058083473436, -0.059307577544, 0.060563089366, -0.061851263338, 0.063173427716, -0.064530993089, 0.065925451887, -0.067358387893, 0.068831485142, -0.070346532543, 0.071905432603, -0.073510217159, 0.075163043515, -0.076866221732, 0.078622213297, -0.080433655641, 0.082303370668, -0.084234385688, 0.086229947754, -0.088293546340, 0.090428936788, -0.092640164280, 0.094931596141, -0.097307948658, 0.099774328270, -0.102336263000, 0.104999760466, -0.107771346705, 0.110658136074, -0.113667891145, 0.116809097747, -0.120091053324, 0.123523965706, -0.127119063887, 0.130888734251, -0.134846668350, 0.139008036349, -0.143389695458, 0.148010428944, -0.152891234646, 0.158055621949, -0.163530113154, 0.169344476033, -0.175532661190, 0.182133087270, -0.189189679503, 0.196752872475, -0.204880757381, 0.213640595834, -0.223110732231, 0.233382953017, -0.244565451601, 0.256786611618, -0.270199886408, 0.284990171234, -0.301382174551, 0.319651524822, -0.340139763175, 0.363274854067, -0.389599543691, 0.419811378014, -0.454819792210, 0.495829045390, -0.544460200350, 0.602932266499, -0.674330493100, 0.762991030732, -0.874986539964, 1.018432099887, -1.202052695478, 1.424368368342, -1.615622176253, 1.343725381358, 1.343725381358, -1.615622176253, 1.424368368342, -1.202052695478, 1.018432099887, -0.874986539964, 0.762991030732, -0.674330493100, 0.602932266499, -0.544460200350, 0.495829045390, -0.454819792210, 0.419811378014, -0.389599543691, 0.363274854067, -0.340139763175, 0.319651524822, -0.301382174551, 0.284990171234, -0.270199886408, 0.256786611618, -0.244565451601, 0.233382953017, -0.223110732231, 0.213640595834, -0.204880757381, 0.196752872475, -0.189189679503, 0.182133087270, -0.175532661190, 0.169344476033, -0.163530113154, 0.158055621949, -0.152891234646, 0.148010428944, -0.143389695458, 0.139008036349, -0.134846668350, 0.130888734251, -0.127119063887, 0.123523965706, -0.120091053324, 0.116809097747, -0.113667891145, 0.110658136074, -0.107771346705, 0.104999760466, -0.102336263000, 0.099774328270, -0.097307948658, 0.094931596141, -0.092640164280, 0.090428936788, -0.088293546340, 0.086229947754, -0.084234385688, 0.082303370668, -0.080433655641, 0.078622213297, -0.076866221732, 0.075163043515, -0.073510217159, 0.071905432603, -0.070346532543, 0.068831485142, -0.067358387893, 0.065925451887, -0.064530993089, 0.063173427716, -0.061851263338, 0.060563089366, -0.059307577544, 0.058083473436, -0.056889588450, 0.055724798156, -0.054588037999, 0.053478306635, -0.052394612322, 0.051336162434, -0.050301865334, 0.049291168807, -0.048303158005, 0.047337052727, -0.046392201827, 0.045467961416, -0.044563673627, 0.043678702474, -0.042812456663, 0.041964390263, -0.041133986518, 0.040320737342, -0.039524148180, 0.038743749150, -0.037979087851, 0.037229732310, -0.036495285507, 0.035775348710, -0.035069554322, 0.034377533547, -0.033698936891, 0.033033425105, -0.032380675289, 0.031740377067, -0.031112233682, 0.030495960269, -0.029891280351, 0.029297928606, -0.028715646422, 0.028144185176, -0.027583302645, 0.027032768362, -0.026492356476, 0.025961852241, -0.025441045646, 0.024929734343, -0.024427722029, 0.023934820944, -0.023450847862, 0.022975626811, -0.022508985151, 0.022050752622, -0.021600764631, 0.021158860608, -0.020724890508, 0.020298700759, -0.019880161002, 0.019469113392, -0.019065434904, 0.018668981115, -0.018279622730, 0.017897245649, -0.017521725210, 0.017152932435, -0.016790748204, 0.016435061368, -0.016085765838, 0.015742752141, -0.015405902385, 0.015075112991, -0.014750303007, 0.014431364261, -0.014118168124, 0.013810681220, -0.013508755133, 0.013212332134, -0.012921307124, 0.012635598299, -0.012355120008, 0.012079788179, -0.011809518412, 0.011544230106, -0.011283845610, 0.011028286872, -0.010777479194, 0.010531347436, -0.010289816845, 0.010052815028, -0.009820272961, 0.009592119185, -0.009368288471, 0.009148710425, -0.008933319707, 0.008722049468, -0.008514836958, 0.008311618786, -0.008112333834, 0.007916920630, -0.007725317598, 0.007537465733, -0.007353305467, 0.007172781223, -0.006995833709, 0.006822411334, -0.006652453639, 0.006485910732, -0.006322727145, 0.006162849817, -0.006006228231, 0.005852809600, -0.005702541972, 0.005555377653, -0.005411266138, 0.005270156596, -0.005132001194, 0.004996752688, -0.004864364084, 0.004734784003, -0.004608044835, 0.004483723159, -0.004362665764, 0.004243770692, -0.004127461044, 0.004013833784, -0.003902780174, 0.003794173073, -0.003687936658, 0.003584041643, -0.003482479159, 0.003383233823, -0.003286272943, 0.003191555178, -0.003099031904, 0.003008649713, -0.002920363984, 0.002834138862, -0.002749934079, 0.002667726157, -0.002587478603, 0.002509164415, -0.002432749342, 0.002358200535, -0.002285481842, 0.002214557806, -0.002145392318, 0.002077949490, -0.002012195988, 0.001948097744, -0.001885623961, 0.001824743557, -0.001765429547, 0.001707652260, -0.001651385820, 0.001596600113, -0.001543265948, 0.001491353537, -0.001440834188, 0.001391678920, -0.001343861051, 0.001297351425, -0.001252120873, 0.001208141683, -0.001165386493, 0.001123831678, -0.001083451076, 0.001044228783, -0.001006124024, 0.000969132891, -0.000933209570, 0.000898346618, -0.000864524888, 0.000831710093, -0.000799879898, 0.000769017578, -0.000739100882, 0.000710106410, -0.000682009867, 0.000654789012, -0.000628429716, 0.000602911519, -0.000578200926, 0.000554284844, -0.000531162622, 0.000508779123, -0.000487148092, 0.000466230156, -0.000446020258, 0.000426497302, -0.000407643761, 0.000389441103, -0.000371873556, 0.000354925219, -0.000338579892, 0.000322822614, -0.000307635613, 0.000293002557, -0.000278908335, 0.000265338906, -0.000252279201, 0.000239717132, -0.000227635589, 0.000216021912, -0.000204860855, 0.000194140539, -0.000183847610, 0.000173970649, -0.000164496496, 0.000155412681, -0.000146707831, 0.000138369816, -0.000130388780, 0.000122752228, -0.000115452479, 0.000108473888, -0.000101811908, 0.000095450865, -0.000089382883, 0.000083598110, -0.000078084681, 0.000072835122, -0.000067841979, 0.000063093698, -0.000058581637, 0.000054298192, -0.000050233909, 0.000046380231, -0.000042729681, 0.000039274933, -0.000036008008, 0.000197695583]'
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    marker1: '-1'
    size: '2000'
    style1: '1'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '125'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '125'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '125'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '125'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '125'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0_2
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17018
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_const_vxx_0_4, '0']
- [analog_const_source_x_1, '0', epy_block_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_frequency_modulator_fc_0_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [analog_frequency_modulator_fc_0_0_1, '0', blocks_multiply_const_vxx_0_2, '0']
- [analog_frequency_modulator_fc_0_0_2, '0', blocks_multiply_const_vxx_0_3, '0']
- [analog_random_source_x_0, '0', blocks_repack_bits_bb_0_0, '0']
- [analog_random_source_x_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [analog_random_source_x_0_0_0, '0', blocks_repack_bits_bb_0_0_0_0, '0']
- [analog_random_source_x_0_0_1, '0', blocks_repack_bits_bb_0_0_0_1, '0']
- [analog_random_source_x_0_0_2, '0', blocks_repack_bits_bb_0_0_0_2, '0']
- [analog_random_source_x_0_1, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_0_1_0, '0', digital_psk_mod_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_const_vxx_1, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_add_const_vxx_1_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [blocks_add_const_vxx_1_0_0, '0', analog_frequency_modulator_fc_0_0_0, '0']
- [blocks_add_const_vxx_1_0_1, '0', analog_frequency_modulator_fc_0_0_1, '0']
- [blocks_add_const_vxx_1_0_2, '0', analog_frequency_modulator_fc_0_0_2, '0']
- [blocks_add_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_1_0, '0']
- [blocks_file_source_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_repack_bits_bb_0_0_0_0, '0']
- [blocks_file_source_0_0_0_1, '0', blocks_repack_bits_bb_0_0_0_1, '0']
- [blocks_file_source_0_0_0_2, '0', blocks_repack_bits_bb_0_0_0_2, '0']
- [blocks_float_to_complex_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_3, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_4, '0', blocks_add_xx_0, '6']
- [blocks_multiply_const_vxx_0_5, '0', blocks_add_xx_0, '5']
- [blocks_multiply_const_vxx_1, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0_5, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0_5, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_repack_bits_bb_0_0_0_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [blocks_repack_bits_bb_0_0_0_1, '0', digital_chunks_to_symbols_xx_0_0_1, '0']
- [blocks_repack_bits_bb_0_0_0_2, '0', digital_chunks_to_symbols_xx_0_0_2, '0']
- [blocks_throttle2_0, '0', zeromq_pub_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', root_raised_cosine_filter_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0_1, '0', root_raised_cosine_filter_0_0_1, '0']
- [digital_chunks_to_symbols_xx_0_0_2, '0', root_raised_cosine_filter_0_0_2, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0, '0']
- [digital_psk_mod_0, '0', blocks_multiply_xx_0_0, '0']
- [epy_block_0, '0', blocks_add_const_vxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_const_vxx_1, '0']
- [rational_resampler_xxx_0_0, '0', blocks_add_const_vxx_1_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_add_const_vxx_1_0_0, '0']
- [rational_resampler_xxx_0_0_1, '0', blocks_add_const_vxx_1_0_1, '0']
- [rational_resampler_xxx_0_0_2, '0', blocks_add_const_vxx_1_0_2, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [root_raised_cosine_filter_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [root_raised_cosine_filter_0_0_1, '0', rational_resampler_xxx_0_0_1, '0']
- [root_raised_cosine_filter_0_0_2, '0', rational_resampler_xxx_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
